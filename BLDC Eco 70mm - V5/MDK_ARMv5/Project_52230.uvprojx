# Keil uVision project Project_52230.uvprojx, settings and files
target HT32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HT32F52230 Holtek
  pack: Holtek.HT32_DFP.1.0.38
  cpu: IROM(0x00000000-0x00007BFF) IRAM(0x20000000-0x20000FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: HT32 +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52230_SK, USE_HT32F52220_30, USE_MEM_HT32F52230
  c include: ..\;..\library\CMSIS\Include;..\library\Device\Holtek\HT32F5xxxx\Include;..\library\HT32F5xxxx_Driver\inc;..\library\HT32_USBD_Library\inc;..\utilities;..\Inc
  asm define: USE_HT32_CHIP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32f5xxxx_01_it.c
    ../Src/: AL01_board_motor_dev_rev2019_01.c AL00_micro_ht32f52230.c AL02_inverter_1phase.c AL03_motor_1phase_driver.c
    ../Inc/: AL00_micro_ht32f52230.h AL02_inverter_1phase.h AL03_motor_1phase_driver.h
  group Config
    ../: ht32f5xxxx_conf.h
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32f5xxxx_02.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_01.s
  group Library
    ../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_wdt.c
  group Retarget
    ../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../utilities/: ht32_board.c
    ../utilities/common/: i2c_eeprom.c spi_flash.c spi_lcd.c
  group Doc
    ../: readme.txt
